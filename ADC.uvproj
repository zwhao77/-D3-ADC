# Keil uVision project ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\ADC0808;.\src\DAC0832;.\src\delay;.\src\Init;.\src\IO8155;.\src\reflash;.\src\voltCalc
  group Source Group 1
    ./: STARTUP.A51
    ./src/main/: main.c
    ./src/ADC0808/: ADC0808.c
    ./src/DAC0832/: DAC0832.c
    ./src/delay/: delay.c
    ./src/Init/: Init.c
    ./src/IO8155/: IO8155.c
    ./src/reflash/: reflash.c
    ./src/voltCalc/: voltCalc.c voltCalc.h
